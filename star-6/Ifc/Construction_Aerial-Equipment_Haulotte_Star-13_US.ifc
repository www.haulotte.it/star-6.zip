Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-09-16T13:29:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 16 13:29:47 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{30E2C7C3-F57F-4012-92B4-72E890FAD694}\ifc * Database version: 5507 * Database creation date: Wed Sep 16 13:29:43 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 16 13:29:44 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 16 13:29:44 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Star 13, Construction_Aerial-Equipment_Haulotte_Star-13_US:Star 13:4036214
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Working_Area, Metal - Haulotte - Black, Red, Metal - Haulotte - Grey, Metal - Haulotte - Yellow
Type - Autre(Type) - Catégorie: Equipement spécialisé; Machine Weight: 830 kg - (1829.84 lb); Nom de la famille: Construction_Aerial-Equipment_Haulotte_Star-13_US
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Vertical Mast; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Star 13; Nom du type: Star 13; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/star-6; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte-usa.com/
Type - Données(Type) - Batteries: 12 V - 150 Ah; Driveable at Full Height up to: 3.8 m - (149.61 in); Drive Speed: 4.5 - 0.8km/h - (2.8 - 0.5 mph); Ground Clearance: 0.06 m - (2.36 in); Height - Stowed: 1.71 m - (67.32 in); Length: 1.4 m - (55.12 in); Length Extension: 0.4 m - (15.75 in); Lift Capacity – Inside: 230 kg - (507.06 lb); Max Ground Pressure of Wheel on Paved Ground: 12 daN/cm2; Platform Height: 3.8 m - (149.61 in); Platform Size: 0.77x1.38 m - (30.31x54.13 in); Tilt: 3°; Tires: 0.318x0.108 mm / 12.52x4.25 in; Turning Radius - Inside: 0.143 m - (5.63 in); Turning Radius - Outside: 1.565 m - (61.61 in); Wheelbase: 1.075 m - (42.32 in); Width: 0.79 m - (31.10 in); Working Height: 5.8 m - (228.34 in)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Star 13
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - A2: yes; A2 lngt: 2.565 m; A2 lngt cntrl: 2.565 m; A3: yes; A3 lngt: 1.3 m; A3 lngt cntl: 1.3 m; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Star-13_US: Star 13; Famille et type: Construction_Aerial-Equipment_Haulotte_Star-13_US: Star 13; H CTRL: 3.8 m; ID du type: Construction_Aerial-Equipment_Haulotte_Star-13_US: Star 13; Type: Construction_Aerial-Equipment_Haulotte_Star-13_US: Star 13
Construction - Extension Desk Length: 0.4 m; Platform Height: 3.8 m; Reach Diagram: yes; Turning Radius: yes; Working Area: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 31.2415 m2; Volume: 10.8988 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
