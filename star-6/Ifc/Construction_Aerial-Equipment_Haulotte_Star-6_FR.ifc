Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-09-16T13:32:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 16 13:32:44 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{C55DA326-BD42-446F-B64E-C360B8653FEA}\ifc * Database version: 5507 * Database creation date: Wed Sep 16 13:32:40 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 16 13:32:41 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 16 13:32:41 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Star 6, Construction_Aerial-Equipment_Haulotte_Star-6_FR:Star 6:4036209
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Working_Area, Metal - Haulotte - Black, Red, Metal - Haulotte - Grey, Metal - Haulotte - Yellow
Type - Autre(Type) - Catégorie: Equipement spécialisé; Nom de la famille: Construction_Aerial-Equipment_Haulotte_Star-6_FR
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Mât vertical; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Star 6; Nom du type: Star 6; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/star-6; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.fr
Type - Données(Type) - Batteries: 12 V - 150 Ah; Capacité Maximum - Intérieur: 230 kg - (507.06 lb); Devers: 3°; Dimensions Plateforme: 0.77x1.38 m - (30.31x54.13 in); Empattement: 1.075 m - (42.32 in); Garde au Sol: 0.06 m - (2.36 in); Hauteur Maximale de Translation: 3.8 m - (149.61 in); Hauteur Plateforme: 3.8 m - (149.61 in); Hauteur Repliée: 1.71 m - (67.32 in); Hauteur Travail: 5.8 m - (228.34 in); Largeur Hors Tout: 0.79 m - (31.10 in); Longueur Extension: 0.4 m - (15.75 in); Longueur Hors Tout: 1.4 m - (55.12 in); Masse Machine (CE): 830 kg - (1829.84 lb); Pneus: 0.318x0.108 mm / 12.52x4.25 in; Pression Max au Sol: 12 daN/cm2; Rayon de Braquage Exterieur: 1.565 m - (61.61 in); Rayon de Braquage Interieur: 0.143 m - (5.63 in); Vitesse de Translation: 4.5 - 0.8km/h - (2.8 - 0.5 mph)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Star 6
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - A2: yes; A2 lngt: 2.565 m; A2 lngt cntrl: 2.565 m; A3: yes; A3 lngt: 1.3 m; A3 lngt cntl: 1.3 m; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Star-6_FR: Star 6; Famille et type: Construction_Aerial-Equipment_Haulotte_Star-6_FR: Star 6; H CTRL: 3.8 m; ID du type: Construction_Aerial-Equipment_Haulotte_Star-6_FR: Star 6; Type: Construction_Aerial-Equipment_Haulotte_Star-6_FR: Star 6
Construction - Abaque de Travail: yes; Extension Plateforme: 0.4 m; Hauteur de Plateforme: 3.8 m; Rayon de Braquage Exterieur: yes; Zone de Travail: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 31.2295 m2; Volume: 10.8987 m3
Graphismes - Marque: yes
Phase de construction - Phase de création: Nouvelle construction
